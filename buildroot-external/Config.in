## buildroot-external/Config.in
```kconfig
menu "Additional drivers, libraries and/or applications"
	source "$BR2_EXTERNAL_YROS_PATH/package/yrosd/Config.in"
endmenu
```
