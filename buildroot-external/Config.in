## buildroot-external/package/yrosd/Config.in
```kconfig
config BR2_PACKAGE_YROSD
	bool "yrosd"
	help
	  Yet another Operating System Daemon

	  https://github.com/xSlendiX/yrosd
```
